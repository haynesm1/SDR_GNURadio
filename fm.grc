options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm
    output_language: python
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"192.168.1.100"'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    outputmsgname: value
    showports: 'False'
    start: '80'
    step: '0.1'
    stop: '120'
    value: '100.0'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: rx_samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: eclypse_z7_source_0
  id: eclypse_z7_source
  parameters:
    addr: str(addr)
    corr: '0'
    freq: rx_freq*1000000
    port: '1001'
    rate: rx_samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: '1'
    gain: '1'
    samp_rate: rx_samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '4096'
    port: '1001'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rx_samp_rate
    fc: rx_freq*1000000
    fftsize: '1024'
    name: ''
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [network_udp_source_0, '0', low_pass_filter_0, '0']
- [network_udp_source_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
